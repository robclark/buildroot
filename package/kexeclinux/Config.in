## package/kexeclinux/Config.in
```kconfig
config BR2_PACKAGE_KEXECLINUX
	bool "kexeclinux"
	help
	    Silly Embedded (Distro) Hacks
```
